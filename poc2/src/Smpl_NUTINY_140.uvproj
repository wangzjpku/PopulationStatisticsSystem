# Keil uVision project Smpl_NUTINY_140.uvproj, settings and files
target APC_Winterl_NUTINY_140 (ARM-ADS)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: apc_winter
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c define: NUC140
  c include: ..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    D:/Nuvoton/BSP Library/NUC100SeriesBSP_CMSIS_v1.05.003/CMSIS/CM0/CoreSupport/: core_cm0.c
    D:/Nuvoton/BSP Library/NUC100SeriesBSP_CMSIS_v1.05.003/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    D:/Nuvoton/BSP Library/NUC100SeriesBSP_CMSIS_v1.05.003/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: log.h main.c counter_people.c counter_people.h sample_data.h system.h uart.c uart.h sensor.c sensor.h slave.h log.c pc.h master.h system.c pc.c common.h led.h channel.c channel.h slave.c
  group Library files
    D:/Nuvoton/BSP Library/NUC100SeriesBSP_CMSIS_v1.05.003/NuvotonPlatform_Keil/Src/Driver/: DrvGPIO.c DrvRTC.c DrvSYS.c DrvTIMER.c DrvUART.c retarget.c DrvADC.c DrvPWM.c DrvI2C.c DrvI2S.c DrvPDMA.c
